Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Slidedrain-Sluk2-Mansjett.IFC
Time: 2022-10-07T13:22:10
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BIM-210067-007simple_2 deg exit pipe
In: Default Storey
PredefinedType: ELEMENT; Material: 1.4404

# IfcBuildingElementProxy: BIM-210067-009simple
In: Default Storey
PredefinedType: ELEMENT; Material: 1.4404

# IfcBuildingElementProxy: VannlåsPlaceholdersimple
In: Default Storey
PredefinedType: ELEMENT; Material: 1.4404

# IfcElementAssembly: Slidedrain-Sluk2-Mansjett
In: Default Storey
SolidWorks Custom Properties - Date: 07.10.2022; PartNo: 116009-A0; Revision: 01; Tolerance: ISO 2768-mK; Weight: 11529; Weight unit: kg
